# Repository ergeha/UG_MKII

File README.md:

# Power Supply with EMI-Filter

Multi-staged EMI-filter for 12V switch mode power supplies. The board outputs 12VDC and 5VDC. 

Schematic:

Frontside (Rendering):

Backside (Rendering):

PCB Front:

PCB Back:

## KiCad design LM2679/LM2679.kicad_pcb

Parts:
C1: 180µF; CP_Elec_8.3x8.3_Panasonic_SVPF_E7; Rating 20V; Tolerance ±20%; MPN 20SVPF180M
C2: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; Rating 35V; Tolerance ±20%; MPN 0805DC104MAT2A
C3, C4: 10nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; Rating 50V; Tolerance ±5%; MPN CGA4C2C0G1H103J060AA
C5: 330µF; CP_Elec_10.3x10.3_Panasonic_SVPF_F12; Rating 16V; Tolerance ±20%; MPN 16SVP330M
D1: 850mV @ 20A; TO-263-2_TabPin1_HandSoldering; MPN STPS20M100SG-TR
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3_DIN965
J1: INPUT; TerminalBlock_Phoenix_SPTAF-1x02_P5.00mm_Angle45; MPN 1862275
J2: OUTPUT; TerminalBlock_Phoenix_SPTAF-1x02_P5.00mm_Angle45; MPN 1862275
L1: 10µH 10A; L_Vishay_IHLP-5050_HandSolder; Tolerance ±20%; MPN IHLP5050FDER100M01
R1: 4.99kΩ; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; Tolerance ±1%; MPN TNPW08054K99FEEA
U1: LM2679SX-5.0/NOPB; TO-263-7_TabPin8_HandSoldering; MPN LM2679SX-5.0/NOPB

Connections:
+5V: C5.1, J2.1, J2.2, L1.2, U1.6 (FB)
+12V: C1.1, C2.1, J1.1, J1.2, U1.2 (INPUT)
GND: C1.2, C2.2, C3.2, C5.2, D1.2 (A), J1.3, J1.4, J2.3, J2.4, R1.2, U1.4 (GND)
unnamed: C3.1, U1.7 (SS)
unnamed: C4.1, D1.1 (K), L1.1, U1.1 (SWITCH)
unnamed: C4.2, U1.3 (CB)
unnamed: R1.1, U1.5 (CA)

Notes on the sheet:
Buck Regulator
Input: 11.8 - 13.8VDC Input(I): 2.24A Output: 5V (5A max.) ƒ(sw): 260kHz
Mounting Holes

Board: 2 copper layers, 61.2 x 36.8 mm, 15 parts (0 on the bottom side), 7 nets.

File LM2679/LM2679_BOM.csv:

Reference,Value,DCR,Impedence ,Power,Rating,SRF,Tolerance,MPN,Manufacturer,Datasheet
C1,180µF,~,25mΩ,~,20V,~,±20%,20SVPF180M,Panasonic Electronic Components,https://industrial.panasonic.com/ww/products/capacitors/poly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
C2,100nF,~,~,~,35V,~,±20%,0805DC104MAT2A,AVX Corporation,https://datasheets.avx.com/X7RDielectric.pdf
C3,10nF,~,~,~,50V,~,±5%,CGA4C2C0G1H103J060AA,TDK Corporation,https://product.tdk.com/en/system/files?file=dam/doc/product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
C4,10nF,~,~,~,50V,~,±5%,CGA4C2C0G1H103J060AA,TDK Corporation,https://product.tdk.com/en/system/files?file=dam/doc/product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
C5,330µF,~,16mΩ,~,16V,~,±20%,16SVP330M,Panasonic Electronic Components,https://industrial.panasonic.com/ww/products/capacitors/poly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
D1,850mV @ 20A,~,~,~,~,~,~,STPS20M100SG-TR,STMicroelectronics,https://www.st.com/content/ccc/resource/technical/document/d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
H1,M3,~,~,~,~,~,~,~,~,~
H2,M3,~,~,~,~,~,~,~,~,~
H3,M3,~,~,~,~,~,~,~,~,~
H4,M3,~,~,~,~,~,~,~,~,~
J1,INPUT,~,~,~,~,~,~,1862275,Phoenix Contact,~
J2,OUTPUT,~,~,~,~,~,~,1862275,Phoenix Contact,~
L1,10µH 10A,16.5mΩ,~,~,~,10MHz,±20%,SRP1265A-100M,Bourns Inc.,https://www.bourns.com/docs/Product-Datasheets/SRP1265A.pdf
R1,4.99kΩ,~,~,0.2W,~,,±1%,TNPW08054K99FEEA,Vishay Dale,https://www.vishay.com/docs/28758/tnpw_e3.pdf
U1,LM2679SX-5.0/NOPB,~,~,~,~,~,~,LM2679SX-5.0/NOPB,Texas Instruments,https://www.ti.com/lit/ds/symlink/lm2679.pdf?ts=1619264190615

## KiCad design MCP3208/MCP3208.kicad_pcb

Parts:
C1: 0.1µF; CP_Elec_4x4.5_HandSolder; Rating 50V; Tolerance ±20%; MPN UWP1H0R1MCL1GB
C2: 1000pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; Rating 16V; Tolerance ±10%; MPN C0805C102K4RACTU
C3: 22µF; CP_Elec_5x5.3_HandSolder; Rating 16V; Tolerance ±20%; MPN UWT1C220MCL1GB
C4: 0.1µF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; Rating 16V; Tolerance ±10%; MPN C0805C104K4RACTU
C5: 10µF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; Rating 10V; Tolerance ±10%; MPN C0805C106K8RACTU
C6, C7, C8: 1µF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; Rating 16V; Tolerance ±5%; MPN C0805C105J4RAC7025
C9, C10, C11, C12: 47µF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; Rating 10V; Tolerance ±10%; MPN C1210C476K8RAC7800
FB1: 21Ω @ 1MHz; FIL_NFZ32BW210HN11L_HandSolder; MPN NFZ32BW210HN11L
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3_ISO14580
J1: 5V; PinHeader_1x02_P2.54mm_Vertical
J2: SPI; PinHeader_1x04_P2.54mm_Vertical
J3: CH4; PinHeader_1x03_P2.54mm_Vertical
J4: CH3; PinHeader_1x03_P2.54mm_Vertical
J5: CH2; PinHeader_1x03_P2.54mm_Vertical
J6: CH1; PinHeader_1x03_P2.54mm_Vertical
R1: 10kΩ; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; Tolerance ±1%; MPN RCS080510K0FKEA
R2, R3: 1kΩ; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; Tolerance ±0.1%; MPN TNPW08051K00BEEA
R4, R5, R6, R7: 68kΩ; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; Tolerance ±1%; MPN RCS080568K0FKEA
U1: MCP1541; SOT-23_Handsoldering_MCP; MPN MCP1541T-I/TT
U2: MCP6021; SOIC-8_MCP_HandSolder; MPN MCP6021-I/SN
U3: MCP3208; SOIC-16_MCP_HandSolder; MPN MCP3208T-BI/SL

Connections:
+5V: C1.1, C2.1, C3.1, FB1.2, J1.1
/SPI.CLK: J2.1, U3.13 (CLK)
/SPI.CS0: J2.4, U3.10 (~CS~/SHDN)
/SPI.MISO: J2.2, U3.12 (Dout)
/SPI.MOSI: J2.3, U3.11 (Din)
CH.0: R2.2, R3.1, U3.1 (CH0)
CH.1: C12.2, R7.2, U3.2 (CH1)
CH.2: C11.2, R6.2, U3.4 (CH3)
CH.3: C10.2, R5.2, U3.6 (CH5)
CH.4: C9.2, R4.2, U3.8 (CH7)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, J1.2, J3.1, J4.1, J5.1, J6.1, R3.2, U1.3 (Vss), U2.4, U3.9 (DGND), U3.14 (AGND)
unnamed: C5.1, R1.2, U1.2 (Vout)
unnamed: C6.2, R1.1, U2.3 (+)
unnamed: C8.2, U2.2 (-), U2.6, U3.15 (Vref)
unnamed: J3.3, R4.1
unnamed: J4.3, R5.1
unnamed: J5.3, R6.1
unnamed: J6.3, R7.1
V.IN: C4.1, C7.2, FB1.1, J3.2, J4.2, J5.2, J6.2, R2.1, U1.1 (Vin), U2.7, U3.16 (Vdd)

Notes on the sheet:
Mounting Holes
12-Bit Analog-Digital Converter Board

Board: 2 copper layers, 52.3 x 29.7 mm, 33 parts (0 on the bottom side), 19 nets.

## KiCad design UG_Power-Input/UG_Power-Input.kicad_pcb

Parts:
C1: 100µF 50V; CP_Radial_D8.0mm_P5.00mm; Part-Nr. EEU-FM1H101B; Mouser-Nr 667-EEU-FM1H101B
C2: 10µF 50V; C_MLCC_W5.5mm_L4.0mm_P2.50mm; Part-Nr. RDEC71H106K3S1H03A; Mouser-Nr 81-RDEC71H106K3S1H3A
C3: 1µF 50V; C_MLCC_W5.5mm_L3.15mm_P2.50mm; Part-Nr. RDER71H105K2S1H03A; Mouser-Nr 81-RDER71H105K2S1H3A
C4, C9: 100nF 50V; C_MLCC_W5.0mm_L2.5mm_P2.50mm; Part-Nr. RDER71H104K0S1H03A; Mouser-Nr 81-RDER71H104K0S1H3A
C5, C7, C10: 10nF 50V; C_MLCC_W5.0mm_L2.5mm_P2.50mm; Part-Nr. RDER71H103K0S1H03A; Mouser-Nr 81-RDER71H103K0S1H3A
C6: 1nF 50V; C_MLCC_W5.0mm_L2.5mm_P2.50mm; Part-Nr. RDER71H102K0S1H03A; Mouser-Nr 81-RDER71H102K0S1H3A
C8: 180µF 35V; CP_Radial_D8.0mm_P5.00mm; Part-Nr. EEU-FR1V181B; Mouser-Nr 667-EEU-FR1V181B
C11: 330µF 50V; CP_Radial_D10.0mm_P5.00mm; Part-Nr. EEU-FR1H331LB; Mouser-Nr 667-EEU-FR1H331LB
C12: 10µF 50V; C_MLCC_W5.5mm_L4.0mm_P2.50mm; Part-Nr. RDEC71H106K3S1H03A; Mouser-Nr 81-RDER71H103K0S1H3A
C13: 200µF 100V; CP_Radial_D12.5mm_P5.00mm; Part-Nr. EGXF101ELL201MK25S; Mouser-Nr 661-EGXF101ELL201MK2
D1: STPS5L60; D_DO-201AE_P5.08mm_Vertical_KathodeUp; Forward Voltage 520mV @ 5A; Part-Nr. STPS5L60; Mouser-Nr 511-STPS5L60
F1: 5A 10.3s; Fuse_Bourns_MF-RHT200; Part-Nr. MF-R250-2-10
F2: 3.2A 8s; Fuse_Bourns_MF-RHT100; Part-Nr. MF-R160-2
FL1: 2.2mH 8A; L_CommonMode_Wuerth_WE-CMB-XL; Part-Nr. 7448258022; Mouser-Nr 710-7448258022
H1, H4: ø3.2; MountingHole_3.2mm_M3
H2: ø3.5; MountingHole_3.5mm
H3: ø3.5; MountingHole_3.5mm_Pad_Via
HS1: HSS-B20-NPR-02; Heatsink_CUI_HSS-B20-NPR-02; Part-Nr. HSS-B20-NPR-02
J1: 12V IN; TerminalBlock_Weidemueller_LMF-1330180000_1x02_P5.00mm_Vert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; Rating 7A MAX; Part-Nr. 1330180000
J2: 5V OUT; TerminalBlock_Weidemueller_LMF-1330180000_1x02_P5.00mm_Vert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; Rating 5A MAX; Part-Nr. 1330180000
J3: 12V OUT; TerminalBlock_Weidemueller_LMF-1330180000_1x02_P5.00mm_Vert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; Rating 3.2A MAX; Part-Nr. 1330180000
L1, L3: 100µH 7A; 2312-V-RC; Part-Nr. 2312-V-RC
L2, L4: 10µH 7.9A; L_Radial_D13.7mm_P7.50mm_Coilcraft_RFS1412; Tolerance 20%; Part-Nr. RFS1412-103ME
L5: 10µH 11.4A; L_Radial_D14.8mm_P12.00mm_Würth_WE-FAMI; Part-Nr. 744750560100
L6: 1µH 6.9A; L_Radial_D7.8mm_P5.00mm_Würth-Elektronik; Part-Nr. 7447720010
R1: 100kΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; Tolerance 1%; Part-Nr. SFR25H0001003FR500
R2: 4.99kΩ; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; Tolerance 1%; Part-Nr. SFR2500004991FR500
R3: 0Ω; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; Tolerance 1%; Part-Nr. MBB02070Z0000ZCT00
TP1: +IN; TestPoint_Keystone_5000-5004_Miniature; Part-Nr. 5000
TP2: +CMC; TestPoint_Keystone_5000-5004_Miniature; Part-Nr. 5000
TP3: EMI; TestPoint_Keystone_5000-5004_Miniature; Part-Nr. 5000
TP4: -IN; TestPoint_Keystone_5000-5004_Miniature; Part-Nr. 5118
TP5: -CMC; TestPoint_Keystone_5000-5004_Miniature; Part-Nr. 5001
TP6, TP10, TP11: GND; TestPoint_Keystone_5000-5004_Miniature; Part-Nr. 5001
TP7: BCK; TestPoint_Keystone_5000-5004_Miniature; Part-Nr. 5000
TP8: LC; TestPoint_Keystone_5000-5004_Miniature; Part-Nr. 5000
TP9: SW; TestPoint_Keystone_5000-5004_Miniature; Part-Nr. 5001
U1: LM2679; LM2679T-5.0&slash_NOPB; Part-Nr. LM2679T-5.0/NOPB; Mouser-Nr 926-LM2679T-50/NOPB

Connections:
+5V: C13.1, F1.2, L6.2, TP8.1
+12V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C8.1, C9.1, F2.2, L2.2, R1.1, TP3.1, U1.2 (INPUT)
-IN: FL1.2, J1.3, J1.4, R3.1, TP4.1
BUCK.OUT: C11.1, C12.1, L5.2, L6.1, TP7.1, U1.6 (FB)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, D1.2 (A), J2.3, J2.4, J3.3, J3.4, L4.1, R1.2, R2.2, TP6.1, TP10.1, TP11.1, U1.4 (GND)
unnamed: C7.1, D1.1 (K), L5.1, TP9.1, U1.1 (SWITCH)
unnamed: C7.2, U1.3 (CB)
unnamed: C10.1, U1.7 (SS)
unnamed: F1.1, J2.1, J2.2
unnamed: F2.1, J3.1, J3.2
unnamed: FL1.1, J1.1, J1.2, TP1.1
unnamed: FL1.3, L3.1, TP5.1
unnamed: FL1.4, L1.1, TP2.1
unnamed: H3.1, R3.2
unnamed: L1.2, L2.1
unnamed: L3.2, L4.2
unnamed: R2.1, U1.5 (CA)

Notes on the sheet:
Buck Regulator
EMI-Filter
Ground-Plane separation on PCB
Input: 11.8 - 13.8V Input(I): 2.24A Output: 5V (max. 5A) ƒ(sw): 260kHz
Second Stage Output Filter
Capacitors for EMI-Filter: 100Hz to 30MHz; Capacitive Reactance X(C) < 1Ω: X(C) = 1/(2πƒC)
Discharge Resitor for C1
LC-Filter: ƒ(cout) = 11.3MHz
Optional, depedending on IRL measurements
PSU: 7.1A, 85.2W, 120mVp-p @ 20MHz
LC-Filter (L5, C11): ƒ(cout) = 2.7kHz
Inductors for EMI-Filter: 100Hz to 30MHz; Capacitive Inductance X(L) > 100Ω X(L) = 2πƒL
Notes:
Output Connectors
Mounting Holes
IC Power Dissipation: 2.25W

Board: 2 copper layers, 113.5 x 72.9 mm, 46 parts (0 on the bottom side), 17 nets.

File UG_Power-Input/UG_Power-Input_BOM.csv:

Reference,Value,DCR,Forward Voltage,Impedance,Power,Power Dissipation,SRF,Tolerance,Manufacturer,Part-Nr.,Datasheet
C1,100µF 50V,~,~,61mΩ,~,~,~,20 %,Panasonic,EEU-FM1H101B,https://industrial.panasonic.com/cdbs/www-data/pdf/RDF0000/A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
C2,10µF 50V,~,~,~,~,~,~,10 %,Murata,RDEC71H106K3S1H03A,https://search.murata.co.jp/Ceramy/image/img/A01X/G101/ENG/R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
C3,1µF 50V,~,~,~,~,~,~,10 %,Murata,RDER71H105K2S1H03A,https://search.murata.co.jp/Ceramy/image/img/A01X/G101/ENG/R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
C4,100nF 50V,~,~,~,~,~,~,10 %,Murata,RDER71H104K0S1H03A,https://search.murata.co.jp/Ceramy/image/img/A01X/G101/ENG/R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
C5,10nF 50V,~,~,~,~,~,~,10 %,Murata,RDER71H103K0S1H03A,https://search.murata.co.jp/Ceramy/image/img/A01X/G101/ENG/R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
C6,1nF 50V,~,~,~,~,~,~,10 %,Murata,RDER71H102K0S1H03A,https://search.murata.co.jp/Ceramy/image/img/A01X/G101/ENG/R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
C7,10nF 50V,~,~,~,~,~,~,10 %,Murata,RDER71H103K0S1H03A,https://search.murata.co.jp/Ceramy/image/img/A01X/G101/ENG/R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
C8,180µF 35V,~,~,56mΩ,~,~,~,20 %,Panasonic,EEU-FR1V181B,https://b2b-api.panasonic.eu/file_stream/pids/fileversion/8157
C9,100nF 50V,~,~,~,~,~,~,10 %,Murata,RDER71H104K0S1H03A,https://search.murata.co.jp/Ceramy/image/img/A01X/G101/ENG/R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
C10,10nF 50V,~,~,~,~,~,~,10 %,Murata,RDER71H103K0S1H03A,https://search.murata.co.jp/Ceramy/image/img/A01X/G101/ENG/R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
C11,330µF 50V,~,~,22mΩ,~,~,~,20 %,Panasonic,EEU-FR1H331LB,https://b2b-api.panasonic.eu/file_stream/pids/fileversion/8157
C12,10µF 50V,~,~,~,~,~,~,10 %,Murata,RDEC71H106K3S1H03A,https://search.murata.co.jp/Ceramy/image/img/A01X/G101/ENG/R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
C13,200µF 100V,~,~,82mΩ,~,~,~,20 %,United Chemi-Con,EGXF101ELL201MK25S,https://www.mouser.de/datasheet/2/420/United-Chemi-Con-1016798.pdf
D1,STPS5L60,~,520mV @ 5A,~,~,~,~,~,STMicroelectronics,STPS5L60,https://www.st.com/content/ccc/resource/technical/document/d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
F1,5A 10.3s,~,~,~,~,~,~,~,Bourns Inc.,MF-R250-2-10,https://www.bourns.com/docs/Product-Datasheets/mfr.pdf
F2,3.2A 8s,~,~,~,~,~,~,~,Bourns Inc.,MF-R160-2,https://www.bourns.com/docs/Product-Datasheets/mfr.pdf
FL1,2.2mH 8A,14mΩ,~,~,~,~,~,~,Würth Elektronik,7448258022,https://www.we-online.de/katalog/datasheet/7448258022.pdf
H1,3.2mm,~,~,~,~,~,~,~,~,~,~
H2,3.5mm,~,~,~,~,~,~,~,~,~,~
H3,3.5mm,~,~,~,~,~,~,~,~,~,~
H4,3.2mm,~,~,~,~,~,~,~,~,~,~
HS1,HSS-B20-NPR-02,~,~,~,~,5.1W @ 75°C,~,~,CUI Devices,HSS-B20-NPR-02,https://www.cuidevices.com/product/resource/hss-b20-npx-02.pdf
J1,12V IN,~,~,~,~,~,~,~,Weidemüller,1330180000,https://media.digikey.com/pdf/Data%20Sheets/Weidmuller%20PDF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
J2,12V OUT,~,~,~,~,~,~,~,Weidemüller,1330180000,https://media.digikey.com/pdf/Data%20Sheets/Weidmuller%20PDF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
J3,5V OUT,~,~,~,~,~,~,~,Weidemüller,1330180000,https://media.digikey.com/pdf/Data%20Sheets/Weidmuller%20PDF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
L1,100µH 7A,37mΩ,~,~,~,~,~,15 %,Bourns Inc.,2312-V-RC,https://www.bourns.com/docs/Product-Datasheets/2300_series.pdf
L2,10µH 7.9A,18mΩ,~,~,~,~,36MHz,20 %,Coilcraft,RFS1412-103ME,https://www.mouser.de/datasheet/2/597/rfs1412-774509.pdf
L3,100µH 7A,37mΩ,~,~,~,~,~,15 %,Bourns Inc.,2312-V-RC,https://www.bourns.com/docs/Product-Datasheets/2300_series.pdf
L4,10µH 7.9A,18mΩ,~,~,~,~,36MHz,20 %,Coilcraft,RFS1412-103ME,https://www.mouser.de/datasheet/2/597/rfs1412-774509.pdf
L5,10µH 11.4A,6.8mΩ,~,~,~,~,~,20 %,Würth Elektronik,744750560100,https://www.we-online.de/katalog/datasheet/744750560100.pdf
L6,1µH 6.9A,13.5mΩ,~,~,~,~,195MHz,30 %,Würth Elektronik,7447720010,https://www.we-online.com/catalog/datasheet/7447720010.pdf
R1,100kΩ,~,~,~,0.5W,~,~,1 %,Vishay,SFR25H0001003FR500,https://www.vishay.com/docs/28722/sfr16s25.pdf
R2,4.99kΩ,~,~,~,0.4W,~,~,1 %,Vishay,SFR2500004991FR500,https://www.vishay.com/docs/28722/sfr16s25.pdf
R3,0Ω,~,~,~,0.6W,~,~,~,Vishay,MBB02070Z0000ZCT00,https://www.vishay.com/docs/28766/mbxsma.pdf
U1,LM2679,~,~,~,~,~,~,~,Texas Instruments,LM2679T-5.0/NOPB,https://www.ti.com/lit/ds/symlink/lm2679.pdf?HQS=dis-mous-nu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

## Commit log

2021-04-18 Test File for GitHub
2021-04-18 First Draft of Buck Regulator with EMI-Filter
2021-04-19 Changes to PCB design
2021-04-19 Changes to silkscreen on back of PCB
2021-04-19 Changes to schematic values, footprints on PCB, BOM
2021-04-19 Changes to PCB & BOM
2021-04-19 Schematic testing
2021-04-19 Schematic added
2021-04-19 Added BOM
2021-04-19 Fix BOM formating
2021-04-19 Fix BOM datasheet links
2021-04-19 BOM fixes
2021-04-19 Silkscreen fixes
2021-04-19 PCB rendering added
2021-04-20 Changes to terminal blocks
2021-04-20 Updated BOM
2021-04-20 Changes to PCB silkscreen
2021-04-20 Schematic update
2021-04-20 Added 3D rendering
2021-04-20 Modify README and clean-up git
2021-04-20 Clean up
2021-05-03 Add ADC circuit
2021-05-03 Add basic Buck Regulator circuit
2021-05-03 Updatee BOMs
2021-05-03 PCB layout changes
2021-05-03 Updates to schematic and PCB
2021-05-03 Add Schematic and Images
2021-05-03 Update BOM
2021-05-04 Changes to schematic layout
2021-05-05 Changes to PCB footprints
2021-05-05 Added vias to PCB
2021-05-05 Changes to footprints
2021-05-06 Inductor changed
2021-05-06 Changes to silkscreen
